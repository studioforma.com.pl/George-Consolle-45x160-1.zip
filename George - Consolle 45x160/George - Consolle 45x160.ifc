Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: George - Consolle 45x160.ifc
Time: 2022-02-08T16:29:00
Author: utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (22)
Name
 | Componente#17 - Description: Componente#17; ObjectType: SketchupComponentInstance
 | Componente#22 - Description: Componente#22; ObjectType: SketchupComponentInstance
 | Componente#14 - Description: Componente#14; ObjectType: SketchupComponentInstance
 | Componente#20 - Description: Componente#20; ObjectType: SketchupComponentInstance
 | Componente#19 - Description: Componente#19; ObjectType: SketchupComponentInstance
 | Componente#16 - Description: Componente#16; ObjectType: SketchupComponentInstance
 | Componente#15 - Description: Componente#15; ObjectType: SketchupComponentInstance
 | Componente#21 - Description: Componente#21; ObjectType: SketchupComponentInstance
 | Componente#18 - Description: Componente#18; ObjectType: SketchupComponentInstance
 | Componente#2 - Description: Componente#2; ObjectType: SketchupComponentInstance
 | Componente#3 - Description: Componente#3; ObjectType: SketchupComponentInstance
 | Componente#1 - Description: Componente#1; ObjectType: SketchupComponentInstance
 | Componente#4 - Description: Componente#4; ObjectType: SketchupComponentInstance
 | Componente#11 - Description: Componente#11; ObjectType: SketchupComponentInstance
 | Componente#5 - Description: Componente#5; ObjectType: SketchupComponentInstance
 | Componente#12 - Description: Componente#12; ObjectType: SketchupComponentInstance
 | Componente#6 - Description: Componente#6; ObjectType: SketchupComponentInstance
 | Componente#7 - Description: Componente#7; ObjectType: SketchupComponentInstance
 | Componente#13 - Description: Componente#13; ObjectType: SketchupComponentInstance
 | Componente#8 - Description: Componente#8; ObjectType: SketchupComponentInstance
 | Componente#10 - Description: Componente#10; ObjectType: SketchupComponentInstance
 | Componente#9 - Description: Componente#9; ObjectType: SketchupComponentInstance
